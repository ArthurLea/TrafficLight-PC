# Keil uVision project traffic_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: traffic_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group source files
    ./: main.c max7219.c led.c interrupt.c key.c uart.c infrared_tube.c
  group head files
    ./: config.h max7219.h led.h key.h uart.h infrared_tube.h
  group util
    ./: config.c readme.txt
